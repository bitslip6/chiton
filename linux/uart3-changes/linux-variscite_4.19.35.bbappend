SRC_URI += "file://my_device_tree_changes.diff"
